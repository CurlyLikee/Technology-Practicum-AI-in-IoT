#ifndef AI_IRRIGATION_OPT_H                                                             // захист заголовкового файлу від повторного включення
#define AI_IRRIGATION_OPT_H                                                             // оголошення макросу модуля оптимізації мікроклімату

#include <Arduino.h>                                                                    // підключення базових типів та математичних функцій

enum AgroStage {                                                                        // перелік режимів мікроклімату тепличного комплексу
  AGRO_OPTIMAL = 0,                                                                     // збалансований стан вологості тепла та освітлення
  AGRO_IRRIGATION_ACTIVE = 1,                                                           // активна фаза дозованого крапельного поливу субстрату
  AGRO_CLIMATE_CORRECTION = 2,                                                          // активна фаза вентиляції або досвічування рослин
  AGRO_DROUGHT_STRESS = 3                                                               // критичне пересихання субстрату з високим випаровуванням
};                                                                                      // завершення переліку режимів тепличного комплексу

struct AgroAiDecision {                                                                 // структура результатів інтелектуальної оптимізації
  AgroStage stage;                                                                      // поточний класифікований режим агрокомплексу
  float evapRateMmDay;                                                                  // прогнозована швидкість випаровування води за добу
  float optSoilThreshPct;                                                               // адаптивний поріг вологості субстрату для старту поливу
  float optTempThreshC;                                                                 // адаптивний поріг температури для ввімкнення витяжки
  int optLightThreshPct;                                                                // оптимальний поріг освітленості для фітопідсвічування
  long pumpDurationSec;                                                                 // розрахована тривалість роботи водяної помпи у секундах
  float waterSavedPct;                                                                  // прогнозований відсоток економії поливної води
  bool pumpRelayOn;                                                                     // рішення моделі на увімкнення реле водяної помпи
  bool ventRelayOn;                                                                     // рішення моделі на увімкнення реле вентилятора
  bool lightRelayOn;                                                                    // рішення моделі на увімкнення реле фітолампи
  const char* llmAutoReport;                                                            // автоматичний текстовий звіт стану теплиці
};                                                                                      // завершення структури результатів оптимізації

class AgroAiOptimizer {                                                                 // клас інтелектуального оптимізатора поливу та клімату
private:                                                                                // приватні змінні стану моделі мікроклімату
  float smoothedEvapRate;                                                               // згладжена швидкість випаровування вологи з субстрату
  long activePumpLeftSec;                                                               // залишковий час активного циклу роботи помпи

public:                                                                                 // публічні методи керування моделлю агрокомплексу
  AgroAiOptimizer() {                                                                   // конструктор початкового стану оптимізатора
    smoothedEvapRate = 2.5f;                                                            // базова початкова швидкість випаровування за добу
    activePumpLeftSec = 0;                                                              // початковий нульовий залишок часу роботи помпи
  }                                                                                     // завершення конструктора класу оптимізатора

  void init() {                                                                         // ініціалізація внутрішніх параметрів агромоделі
    smoothedEvapRate = 2.5f;                                                            // скидання швидкості випаровування до номіналу
    activePumpLeftSec = 0;                                                              // обнулення лічильника циклу водяної помпи
  }                                                                                     // завершення методу початкової ініціалізації

  void tickSecond() {                                                                   // щосекундне оновлення таймера дозованого поливу
    if (activePumpLeftSec > 0) {                                                        // перевірка активного відліку роботи водяної помпи
      activePumpLeftSec--;                                                              // зменшення залишкового часу поливу на одиницю
    }                                                                                   // завершення перевірки активного таймера помпи
  }                                                                                     // завершення методу секундного кроку

  const char* getStageTitle(AgroStage st) {                                             // отримання текстової назви поточного режиму
    if (st == AGRO_DROUGHT_STRESS) {                                                    // перевірка аварійного режиму посухи субстрату
      return "DROUGHT_STRESS";                                                          // повернення рядка критичного дефіциту вологи
    } else if (st == AGRO_IRRIGATION_ACTIVE) {                                          // перевірка режиму активного поливу рослин
      return "IRRIGATION";                                                              // повернення рядка фази подачі води
    } else if (st == AGRO_CLIMATE_CORRECTION) {                                         // перевірка режиму корекції повітря або світла
      return "CLIMATE_CTRL";                                                            // повернення рядка роботи витяжки чи фітолампи
    }                                                                                   // завершення перевірки активних фаз керування
    return "OPTIMAL_ECO";                                                               // повернення рядка оптимального економного стану
  }                                                                                     // завершення методу отримання назви режиму

  AgroAiDecision evaluate(float tC, float hAir, float hSoil, float lPct) {              // комплексний розрахунок правил та часу поливу
    AgroAiDecision res;                                                                 // створення структури підсумкового рішення моделі
    float tempFactor = (tC > 10.0f) ? (tC - 10.0f) * 0.22f : 0.5f;                      // тепловий коефіцієнт інтенсивності випаровування
    float airDryFactor = (100.0f - hAir) * 0.045f;                                      // коефіцієнт сухості повітря теплиці
    float sunFactor = lPct * 0.018f;                                                    // сонячний коефіцієнт радіаційного випаровування
    float instEvap = 0.8f + tempFactor + airDryFactor + sunFactor;                      // миттєва оцінка випаровування води у міліметрах
    if (instEvap > 12.0f) {                                                             // обмеження верхньої межі швидкості випаровування
      instEvap = 12.0f;                                                                 // фіксація максимального показника випаровування
    }                                                                                   // завершення перевірки максимуму випаровування
    smoothedEvapRate = 0.75f * smoothedEvapRate + 0.25f * instEvap;                     // експоненційне згладжування індексу випаровування
    res.evapRateMmDay = smoothedEvapRate;                                               // запис швидкості випаровування у структуру звіту

    float soilThresh = 42.0f + (smoothedEvapRate - 3.0f) * 1.8f;                        // адаптивний розрахунок порогу вологості субстрату
    if (soilThresh < 35.0f) {                                                           // обмеження мінімального порогу запуску поливу
      soilThresh = 35.0f;                                                               // фіксація нижньої межі порогу вологості землі
    } else if (soilThresh > 58.0f) {                                                    // обмеження максимального порогу запуску поливу
      soilThresh = 58.0f;                                                               // фіксація верхньої межі порогу вологості землі
    }                                                                                   // завершення нормування порогу вологості субстрату
    res.optSoilThreshPct = soilThresh;                                                  // збереження оптимізованого порогу поливу

    float tempThresh = 28.0f - (hAir > 75.0f ? 2.0f : 0.0f);                            // оптимізація порогу вентиляції за вологістю повітря
    res.optTempThreshC = tempThresh;                                                    // збереження адаптивного порогу температури
    res.optLightThreshPct = 40;                                                         // встановлення порогу природного світла сорок відсотків

    float soilDeficit = soilThresh - hSoil;                                             // обчислення дефіциту вологи у кореневому шарі
    long calcSec = 0;                                                                   // змінна розрахованої тривалості роботи помпи
    if (soilDeficit > 0.0f) {                                                           // перевірка необхідності увімкнення водяної помпи
      float evapBoost = 1.0f + (smoothedEvapRate / 10.0f);                              // множник корекції тривалості за випаровуванням
      calcSec = (long)(soilDeficit * 1.4f * evapBoost);                                 // розрахунок оптимального часу подачі води
      if (calcSec < 5) {                                                                // обмеження мінімального імпульсу роботи помпи
        calcSec = 5;                                                                    // фіксація мінімальної тривалості поливу п ять секунд
      } else if (calcSec > 90) {                                                        // обмеження максимальної тривалості циклу поливу
        calcSec = 90;                                                                   // фіксація верхньої межі поливу дев яносто секунд
      }                                                                                 // завершення обмеження тривалості роботи помпи
      activePumpLeftSec = calcSec;                                                      // оновлення активного таймера роботи водяної помпи
    } else if (hSoil >= soilThresh + 5.0f) {                                            // перевірка достатнього насичення субстрату вологою
      activePumpLeftSec = 0;                                                            // дострокова зупинка помпи для економії води
    }                                                                                   // завершення розрахунку часу роботи помпи

    res.pumpDurationSec = (calcSec > 0) ? calcSec : activePumpLeftSec;                  // запис рекомендованого часу поливу у звіт
    res.pumpRelayOn = (soilDeficit > 0.0f) || (activePumpLeftSec > 0);                  // формування сигналу керування реле водяної помпи
    res.ventRelayOn = (tC > tempThresh) || (hAir > 82.0f);                              // формування сигналу керування реле вентилятора
    res.lightRelayOn = (lPct < (float)res.optLightThreshPct);                           // формування сигналу керування реле фітолампи

    float baseFixedSec = 120.0f;                                                        // базова тривалість некерованого поливу сто двадцять секунд
    float usedSec = (float)res.pumpDurationSec;                                         // поточна оптимізована тривалість роботи помпи
    float saved = ((baseFixedSec - usedSec) / baseFixedSec) * 100.0f;                   // обчислення відсотка економії водних ресурсів
    if (saved < 0.0f) {                                                                 // перевірка нижньої межі показника економії
      saved = 0.0f;                                                                     // обнулення відсотка при максимальному навантаженні
    } else if (saved > 100.0f) {                                                        // перевірка верхньої межі показника економії
      saved = 100.0f;                                                                   // фіксація стовідсоткової економії в режимі спокою
    }                                                                                   // завершення нормування показника економії води
    res.waterSavedPct = saved;                                                          // збереження відсотка економії води у звіт

    if (hSoil < 22.0f && smoothedEvapRate > 5.5f) {                                     // перевірка умови критичної посухи та спеки
      res.stage = AGRO_DROUGHT_STRESS;                                                  // встановлення аварійного режиму посухи субстрату
      res.llmAutoReport = "LLM REPORT: Drought stress! Max pump and vent active.";      // формування тривожного автозвіту про пересихання
    } else if (res.pumpRelayOn) {                                                       // перевірка активної фази роботи водяної помпи
      res.stage = AGRO_IRRIGATION_ACTIVE;                                               // встановлення режиму дозованого поливу субстрату
      res.llmAutoReport = "LLM REPORT: Precision irrigation active to save water.";     // формування автозвіту про економний полив
    } else if (res.ventRelayOn || res.lightRelayOn) {                                   // перевірка активності вентиляції або фітолампи
      res.stage = AGRO_CLIMATE_CORRECTION;                                              // встановлення режиму корекції мікроклімату теплиці
      res.llmAutoReport = "LLM REPORT: Soil moisture optimal. Adjusting climate.";      // формування автозвіту про стабілізацію клімату
    } else {                                                                            // гілка повністю збалансованого мікроклімату теплиці
      res.stage = AGRO_OPTIMAL;                                                         // встановлення оптимального енергоощадного режиму
      res.llmAutoReport = "LLM REPORT: Greenhouse optimal. All relays in standby.";     // формування автозвіту про ідеальний баланс
    }                                                                                   // завершення класифікації режиму роботи агрокомплексу

    return res;                                                                         // повернення сформованого рішення штучного інтелекту
  }                                                                                     // завершення методу інтелектуальної оптимізації
};                                                                                      // завершення класу оптимізатора мікроклімату теплиці

#endif                                                                                  // завершення блоку захисту заголовкового файлу