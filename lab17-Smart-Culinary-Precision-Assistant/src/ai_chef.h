#ifndef AI_CHEF_H                                                                       // захист заголовкового файлу від повторного включення
#define AI_CHEF_H                                                                       // оголошення макросу модуля кулінарного інтелекту

#include <Arduino.h>                                                                    // підключення базових типів та математичних функцій

enum CookingMode {                                                                      // перелік кулінарних режимів термічної обробки
  MODE_POULTRY = 0,                                                                     // режим приготування філе птиці
  MODE_BEEF_STEAK = 1,                                                                  // режим смаження яловичого стейка
  MODE_BAKING = 2                                                                       // режим випікання борошняних страв
};                                                                                      // завершення переліку кулінарних режимів

enum CookingStage {                                                                     // перелік стадій кулінарного процесу
  STAGE_STANDBY = 0,                                                                    // очікування запуску або налаштування маси
  STAGE_HEATING = 1,                                                                    // активне нагрівання з адаптивним відліком
  STAGE_READY = 2,                                                                      // досягнення повної готовності страви
  STAGE_OVERHEAT = 3                                                                    // попередження про ризик перегріву продукту
};                                                                                      // завершення переліку стадій приготування

struct ChefAiAssessment {                                                               // структура результатів інтелектуального аналізу
  CookingMode recommendedMode;                                                          // рекомендований режим за поточною масою
  CookingStage stage;                                                                   // поточна фаза термічної обробки страви
  float targetTempC;                                                                    // цільова внутрішня температура продукту
  float heatingRateCPerMin;                                                             // динаміка нагрівання у градусах за хвилину
  long remainingSeconds;                                                                // скоригований залишковий час таймера у секундах
  float readinessPercent;                                                               // розрахований відсоток готовності страви
  const char* llmInstruction;                                                           // текстова порада користувачу від моделі
};                                                                                      // завершення структури результатів аналізу

class CulinaryAiChef {                                                                  // клас інтелектуального кулінарного асистента
private:                                                                                // приватні змінні стану теплової моделі
  float lastTempC;                                                                      // попереднє зафіксоване значення температури
  unsigned long lastUpdateMs;                                                           // мітка часу попереднього розрахунку динаміки
  float smoothedRateCPerMin;                                                            // згладжена швидкість зростання температури
  long manualOffsetSec;                                                                 // накопичене зменшення часу активного таймера

public:                                                                                 // публічні методи кулінарного модуля
  CulinaryAiChef() {                                                                    // конструктор початкового стану моделі
    lastTempC = 22.0f;                                                                  // початкова кімнатна температура продукту
    lastUpdateMs = 0;                                                                   // обнулення мітки часу останнього виміру
    smoothedRateCPerMin = 4.5f;                                                         // базова початкова швидкість прогрівання
    manualOffsetSec = 0;                                                                // скидання лічильника відпрацьованих секунд
  }                                                                                     // завершення конструктора класу

  void init(float initialTempC) {                                                       // ініціалізація теплової моделі початковими даними
    lastTempC = initialTempC;                                                           // фіксація стартової температури страви
    lastUpdateMs = millis();                                                            // збереження стартового системного часу
    smoothedRateCPerMin = 4.5f;                                                         // встановлення номінальної швидкості нагрівання
    manualOffsetSec = 0;                                                                // скидання лічильника пройденого часу
  }                                                                                     // завершення методу ініціалізації

  void resetTimerOffset() {                                                             // скидання накопиченого відліку таймера
    manualOffsetSec = 0;                                                                // обнулення відпрацьованих секунд приготування
  }                                                                                     // завершення скидання таймера

  void tickSecond() {                                                                   // крок зменшення часу активного зворотного відліку
    manualOffsetSec++;                                                                  // збільшення кількості відпрацьованих секунд на одиницю
  }                                                                                     // завершення секундного кроку

  float getTargetTemperature(CookingMode mode) {                                        // визначення цільової температури за вибраним режимом
    if (mode == MODE_POULTRY) {                                                         // перевірка режиму приготування птиці
      return 75.0f;                                                                     // норма внутрішньої температури птиці сімдесят п ять градусів
    } else if (mode == MODE_BEEF_STEAK) {                                               // перевірка режиму смаження стейка
      return 65.0f;                                                                     // норма готовності яловичини шістдесят п ять градусів
    }                                                                                   // завершення перевірки основних м ясних режимів
    return 90.0f;                                                                       // норма готовності випічки дев яносто градусів
  }                                                                                     // завершення функції вибору цільової температури

  const char* getModeTitle(CookingMode mode) {                                          // отримання короткої назви активного режиму
    if (mode == MODE_POULTRY) {                                                         // перевірка коду режиму птиці
      return "POULTRY";                                                                 // повернення рядка режиму птиці
    } else if (mode == MODE_BEEF_STEAK) {                                               // перевірка коду режиму стейка
      return "STEAK";                                                                   // повернення рядка режиму стейка
    }                                                                                   // завершення перевірки перших режимів
    return "BAKING";                                                                    // повернення рядка режиму випічки
  }                                                                                     // завершення функції отримання назви режиму

  CookingMode recommendModeByWeight(float weightGrams) {                                // рекомендація оптимального режиму за масою
    if (weightGrams < 450.0f) {                                                         // аналіз легкої порції до чотирьохсот п ятдесяти грамів
      return MODE_BEEF_STEAK;                                                           // рекомендація швидкого обсмаження стейка
    } else if (weightGrams <= 1200.0f) {                                                // аналіз середньої порції до тисячі двохсот грамів
      return MODE_POULTRY;                                                              // рекомендація рівномірного запікання птиці
    }                                                                                   // завершення перевірки середньої ваги
    return MODE_BAKING;                                                                 // рекомендація тривалого випікання великої маси
  }                                                                                     // завершення методу рекомендації режиму

  ChefAiAssessment evaluate(float weightG, float tempC, CookingMode mode, bool run) {   // комплексний розрахунок параметрів приготування
    ChefAiAssessment res;                                                               // створення структури підсумкового звіту моделі
    unsigned long now = millis();                                                       // зчитування поточного системного часу
    unsigned long dtMs = now - lastUpdateMs;                                            // обчислення інтервалу з попереднього заміру

    if (dtMs >= 500) {                                                                  // оновлення градієнта нагрівання кожні пів секунди
      float dTemp = tempC - lastTempC;                                                  // різниця температур між сусідніми вимірами
      float dtMin = (float)dtMs / 60000.0f;                                             // переведення часового інтервалу у хвилини
      if (dtMin > 0.001f && dTemp > 0.01f) {                                            // перевірка наявності реального приросту тепла
        float instRate = dTemp / dtMin;                                                 // миттєва швидкість нагрівання продукту
        if (instRate > 35.0f) {                                                         // обмеження пікових стрибків при русі повзунка
          instRate = 35.0f;                                                             // фіксація верхньої межі швидкості нагрівання
        }                                                                               // завершення обмеження максимальної швидкості
        smoothedRateCPerMin = 0.7f * smoothedRateCPerMin + 0.3f * instRate;             // експоненційне згладжування теплової динаміки
      }                                                                                 // завершення розрахунку додатного градієнта
      lastTempC = tempC;                                                                // оновлення попереднього значення температури
      lastUpdateMs = now;                                                               // оновлення мітки часу теплової моделі
    }                                                                                   // завершення блоку оцінки швидкості нагрівання

    float targetC = getTargetTemperature(mode);                                         // визначення цільової температури поточного режиму
    res.targetTempC = targetC;                                                          // запис цільової температури у структуру звіту
    res.recommendedMode = recommendModeByWeight(weightG);                               // визначення рекомендованого режиму за вагою
    res.heatingRateCPerMin = smoothedRateCPerMin;                                       // запис поточної швидкості прогрівання страви

    float startTempC = 20.0f;                                                           // базова початкова температура сирого продукту
    float progress = (tempC - startTempC) / (targetC - startTempC) * 100.0f;            // обчислення теплової готовності у відсотках
    if (progress < 0.0f) {                                                              // обмеження мінімального відсотка готовності
      progress = 0.0f;                                                                  // встановлення нульового рівня готовності
    } else if (progress > 100.0f) {                                                     // обмеження максимального відсотка готовності
      progress = 100.0f;                                                                // фіксація стовідсоткової готовності страви
    }                                                                                   // завершення нормування відсотка готовності
    res.readinessPercent = progress;                                                    // збереження розрахованого відсотка готовності

    float tempGap = targetC - tempC;                                                    // залишкова різниця до цільової температури
    float massFactor = 0.35f + (weightG / 1000.0f) * 0.85f;                             // ваговий коефіцієнт теплоємності порції
    float rateFactor = 6.0f / (smoothedRateCPerMin + 1.5f);                             // корекція часу за фактичною швидкістю нагрівання
    long predictedSec = 0;                                                              // змінна прогнозованого часу до готовності

    if (tempGap > 0.0f) {                                                               // розрахунок часу якщо цільову температуру не досягнуто
      predictedSec = (long)(tempGap * 12.0f * massFactor * rateFactor);                 // адаптивна оцінка тривалості термічної обробки
      predictedSec -= manualOffsetSec;                                                  // врахування вже відпрацьованих секунд таймера
      if (predictedSec < 0) {                                                           // запобігання від ємному значенню таймера
        predictedSec = 0;                                                               // фіксація завершення зворотного відліку
      }                                                                                 // завершення перевірки нижньої межі часу
    }                                                                                   // завершення розрахунку прогнозованого часу
    res.remainingSeconds = predictedSec;                                                // запис скоригованого залишкового часу у звіт

    if (tempC >= targetC + 8.0f) {                                                      // перевірка небезпечного перегріву страви
      res.stage = STAGE_OVERHEAT;                                                       // встановлення аварійної стадії перегріву
      res.remainingSeconds = 0;                                                         // обнулення таймера при перегріві
      res.llmInstruction = "LLM GUIDE: Overheat alert! Reduce heat and remove dish.";   // порада негайно зменшити нагрів
    } else if (tempC >= targetC || (run && predictedSec == 0)) {                        // перевірка досягнення повної готовності страви
      res.stage = STAGE_READY;                                                          // встановлення стадії завершення приготування
      res.remainingSeconds = 0;                                                         // обнулення лічильника таймера
      res.readinessPercent = 100.0f;                                                    // фіксація повної готовності продукту
      res.llmInstruction = "LLM GUIDE: Target temperature reached. Dish is ready.";     // повідомлення про готовність страви до подачі
    } else if (run) {                                                                   // перевірка активного процесу приготування
      res.stage = STAGE_HEATING;                                                        // встановлення стадії активного нагрівання
      res.llmInstruction = "LLM GUIDE: Heating active. AI adjusts timer by mass.";      // інструкція під час автоматичної корекції часу
    } else {                                                                            // стан очікування старту приготування
      res.stage = STAGE_STANDBY;                                                        // встановлення режиму очікування запуску
      res.llmInstruction = "LLM GUIDE: Place dish on scale and press Start button.";    // порада зважити продукт та запустити таймер
    }                                                                                   // завершення класифікації кулінарної стадії

    return res;                                                                         // повернення сформованого звіту штучного інтелекту
  }                                                                                     // завершення методу оцінки приготування
};                                                                                      // завершення класу інтелектуального кулінара

#endif                                                                                  // завершення блоку захисту заголовкового файлу