#ifndef AI_TRAFFIC_FORECAST_H                                                           // захист заголовкового файлу від повторного включення
#define AI_TRAFFIC_FORECAST_H                                                           // оголошення макросу модуля прогнозування черги

#include <Arduino.h>                                                                    // підключення базових типів та математичних функцій

enum QueueLoadLevel {                                                                   // перелік рівнів завантаженості сервісної точки
  LOAD_LOW = 0,                                                                         // низьке завантаження без черги очікування
  LOAD_MODERATE = 1,                                                                    // штатний робочий потік відвідувачів у залі
  LOAD_HIGH_PEAK = 2,                                                                   // пікове навантаження з подовженим часом очікування
  LOAD_CRITICAL_SURGE = 3                                                               // критичне перевантаження черги що вимагає підсилення
};                                                                                      // завершення переліку рівнів завантаженості

struct QueueAiForecast {                                                                // структура результатів інтелектуального прогнозу черги
  QueueLoadLevel loadLevel;                                                             // класифікований рівень поточного трафіку закладу
  int activeQueueCount;                                                                 // кількість клієнтів які зараз очікують у черзі
  int lastIssuedTicket;                                                                 // номер останнього виданого віртуального талона
  int currentServedTicket;                                                              // номер талона який зараз викликано до вікна
  int totalServedToday;                                                                 // загальна кількість обслугованих клієнтів за зміну
  float avgServiceSec;                                                                  // ковзний середній час обслуговування одного чека
  float estWaitMinutes;                                                                 // прогнозований час очікування нового клієнта у хвилинах
  float arrivalRatePerHour;                                                             // оцінка інтенсивності потоку клієнтів за годину
  const char* llmManagerDigest;                                                         // автоматичний аналітичний дайджест для керівника
};                                                                                      // завершення структури прогнозу клієнтського трафіку

class QueueTrafficAi {                                                                  // клас інтелектуального прогнозування часу очікування
private:                                                                                // приватні змінні стану черги та ковзного вікна
  int issuedCounter;                                                                    // лічильник виданих талонів від початку зміни
  int servedCounter;                                                                    // лічильник обслугованих клієнтів оператором
  float serviceWindowSec[5];                                                            // кільцевий буфер тривалості останніх п яти чеків
  int windowIdx;                                                                        // індекс поточного запису у кільцевому буфері
  int windowCount;                                                                      // кількість заповнених елементів буфера історії
  float smoothedServiceSec;                                                             // згладжена тривалість роботи оператора з клієнтом
  unsigned long lastServiceMs;                                                          // мітка часу попереднього виклику клієнта з черги
  unsigned long lastArrivalMs;                                                          // мітка часу попередньої реєстрації нового талона
  float smoothedArrivalGapSec;                                                          // згладжений інтервал між приходом нових клієнтів

public:                                                                                 // публічні методи керування чергою та моделлю трафіку
  QueueTrafficAi() {                                                                    // конструктор початкового стану моделі черги
    init();                                                                             // виклик початкового скидання всіх лічильників
  }                                                                                     // завершення конструктора класу прогнозування

  void init() {                                                                         // ініціалізація параметрів черги та вікна історії
    issuedCounter = 0;                                                                  // обнулення лічильника виданих клієнтських талонів
    servedCounter = 0;                                                                  // обнулення лічильника завершених обслуговувань
    windowIdx = 0;                                                                      // скидання вказівника позиції кільцевого буфера
    windowCount = 0;                                                                    // обнулення кількості замірів у буфері
    smoothedServiceSec = 90.0f;                                                         // базова норма обслуговування дев яносто секунд
    smoothedArrivalGapSec = 120.0f;                                                     // базовий інтервал приходу клієнтів сто двадцять секунд
    lastServiceMs = millis();                                                           // фіксація стартової мітки часу оператора
    lastArrivalMs = millis();                                                           // фіксація стартової мітки приходу відвідувачів
    for (int i = 0; i < 5; i++) {                                                       // цикл початкового заповнення буфера історії чеків
      serviceWindowSec[i] = 90.0f;                                                      // запис базової тривалості дев яносто секунд
    }                                                                                   // завершення ініціалізації масиву історії
  }                                                                                     // завершення методу початкової ініціалізації

  int registerNewClient() {                                                             // реєстрація нового клієнта з друком віртуального талона
    unsigned long now = millis();                                                       // зчитування поточного системного часу мікроконтролера
    if (issuedCounter > 0) {                                                            // перевірка наявності попередніх реєстрацій у черзі
      float gapSec = (float)(now - lastArrivalMs) / 1000.0f;                            // обчислення інтервалу між двома клієнтами у секундах
      if (gapSec < 5.0f) {                                                              // обмеження мінімального інтервалу при швидких натисканнях
        gapSec = 5.0f;                                                                  // масштабування швидкого натискання до п яти секунд
      } else if (gapSec > 600.0f) {                                                     // обмеження максимального інтервалу простою
        gapSec = 600.0f;                                                                // фіксація верхньої межі інтервалу шістсот секунд
      }                                                                                 // завершення нормування інтервалу приходу клієнта
      float scaledGap = gapSec * 12.0f;                                                 // перерахунок симуляційного часу у реальний масштаб
      if (scaledGap > 600.0f) {                                                         // обмеження масштабованого інтервалу потоку
        scaledGap = 600.0f;                                                             // фіксація максимуму масштабованого інтервалу
      }                                                                                 // завершення перевірки масштабованого інтервалу
      smoothedArrivalGapSec = 0.7f * smoothedArrivalGapSec + 0.3f * scaledGap;          // експоненційне згладжування інтервалу приходу гостей
    }                                                                                   // завершення оновлення статистики вхідного потоку
    lastArrivalMs = now;                                                                // оновлення мітки часу останнього виданого талона
    issuedCounter++;                                                                    // збільшення номера останнього виданого талона
    return issuedCounter;                                                               // повернення присвоєного номера новому клієнту
  }                                                                                     // завершення методу реєстрації нового клієнта

  bool callNextClient() {                                                               // виклик наступного клієнта з черги оператором
    if (servedCounter >= issuedCounter) {                                               // перевірка чи є очікуючі клієнти у черзі
      return false;                                                                     // відмова виклику якщо черга повністю порожня
    }                                                                                   // завершення перевірки порожньої черги
    unsigned long now = millis();                                                       // зчитування моменту виклику чергового талона
    float rawDurSec = (float)(now - lastServiceMs) / 1000.0f;                           // вимірювання фактичного інтервалу роботи оператора
    lastServiceMs = now;                                                                // оновлення мітки часу початку роботи з клієнтом
    float scaledServiceSec = 35.0f + rawDurSec * 10.0f;                                 // масштабування інтервалу симуляції у робочі секунди
    if (scaledServiceSec < 40.0f) {                                                     // обмеження мінімального часу обслуговування чека
      scaledServiceSec = 40.0f;                                                         // фіксація нижньої межі сорок секунд на клієнта
    } else if (scaledServiceSec > 240.0f) {                                             // обмеження максимального часу обслуговування чека
      scaledServiceSec = 240.0f;                                                        // фіксація верхньої межі двісті сорок секунд
    }                                                                                   // завершення нормування тривалості обслуговування

    serviceWindowSec[windowIdx] = scaledServiceSec;                                     // запис нової тривалості у ковзне вікно історії
    windowIdx = (windowIdx + 1) % 5;                                                    // циклічний зсув індексу кільцевого буфера
    if (windowCount < 5) {                                                              // перевірка заповненості буфера попередніх чеків
      windowCount++;                                                                    // збільшення лічильника доступних історичних записів
    }                                                                                   // завершення оновлення розміру вікна історії

    float sumSec = 0.0f;                                                                // змінна суми тривалостей у ковзному вікні
    for (int i = 0; i < windowCount; i++) {                                             // підсумовування тривалостей останніх чеків
      sumSec += serviceWindowSec[i];                                                    // додавання елемента вікна до загальної суми
    }                                                                                   // завершення циклу обчислення суми вікна
    float movingAvg = sumSec / (float)windowCount;                                      // розрахунок ковзного середнього часу оператора
    smoothedServiceSec = 0.6f * movingAvg + 0.4f * scaledServiceSec;                    // поєднання ковзного середнього з останнім чеком
    servedCounter++;                                                                    // збільшення номера поточного викликаного талона
    return true;                                                                        // підтвердження успішного виклику наступного клієнта
  }                                                                                     // завершення методу виклику чергового клієнта

  const char* getLoadTitle(QueueLoadLevel lvl) {                                        // отримання текстової назви рівня завантаженості
    if (lvl == LOAD_CRITICAL_SURGE) {                                                   // перевірка критичного перевантаження черги
      return "CRITICAL_SURGE";                                                          // повернення рядка критичного сплеску трафіку
    } else if (lvl == LOAD_HIGH_PEAK) {                                                 // перевірка пікового завантаження закладу
      return "HIGH_PEAK";                                                               // повернення рядка високого навантаження
    } else if (lvl == LOAD_MODERATE) {                                                  // перевірка помірного робочого потоку
      return "MODERATE";                                                                // повернення рядка штатного завантаження
    }                                                                                   // завершення перевірки активних рівнів трафіку
    return "LOW_IDLE";                                                                  // повернення рядка вільного вікна обслуговування
  }                                                                                     // завершення методу отримання назви рівня

  QueueAiForecast evaluate() {                                                          // комплексний розрахунок прогнозу очікування та звіту
    QueueAiForecast res;                                                                // створення структури підсумкового прогнозу моделі
    int waiting = issuedCounter - servedCounter;                                        // обчислення поточної кількості людей у черзі
    if (waiting < 0) {                                                                  // захист від від ємного значення довжини черги
      waiting = 0;                                                                      // фіксація нульової кількості очікуючих клієнтів
    }                                                                                   // завершення перевірки нижньої межі черги
    res.activeQueueCount = waiting;                                                     // запис кількості очікуючих клієнтів у звіт
    res.lastIssuedTicket = issuedCounter;                                               // запис останнього виданого номера талона
    res.currentServedTicket = servedCounter;                                            // запис поточного обслуговуваного номера талона
    res.totalServedToday = servedCounter;                                               // запис загальної кількості обслугованих клієнтів
    res.avgServiceSec = smoothedServiceSec;                                             // запис ковзного середнього часу роботи оператора

    float trafficRatio = smoothedServiceSec / smoothedArrivalGapSec;                    // співвідношення темпу обслуговування та приходу
    float boost = 1.0f;                                                                 // базовий множник завантаженості черги
    if (trafficRatio > 1.0f) {                                                          // перевірка перевищення потоку над обслуговуванням
      boost = 1.0f + (trafficRatio - 1.0f) * 0.25f;                                     // коефіцієнт нелінійного накопичення черги у пік
    }                                                                                   // завершення розрахунку пікового множника
    float waitSec = (float)waiting * smoothedServiceSec * boost;                        // прогнозований час очікування у секундах
    res.estWaitMinutes = waitSec / 60.0f;                                               // переведення прогнозованого часу очікування у хвилини
    res.arrivalRatePerHour = 3600.0f / smoothedArrivalGapSec;                           // розрахунок прогнозованого трафіку клієнтів за годину

    if (waiting >= 6 || res.estWaitMinutes >= 10.0f) {                                  // перевірка умови критичного перевантаження черги
      res.loadLevel = LOAD_CRITICAL_SURGE;                                              // встановлення критичного рівня завантаженості залу
      res.llmManagerDigest = "LLM DIGEST: Critical queue! Open 2nd counter.";           // дайджест керівнику негайно відкрити другу касу
    } else if (waiting >= 3 || res.estWaitMinutes >= 4.5f) {                            // перевірка умови пікового клієнтського трафіку
      res.loadLevel = LOAD_HIGH_PEAK;                                                   // встановлення високого пікового рівня трафіку
      res.llmManagerDigest = "LLM DIGEST: High visitor peak. Add backup staff.";        // дайджест керівнику підготувати резервного оператора
    } else if (waiting >= 1) {                                                          // перевірка наявності штатної робочої черги
      res.loadLevel = LOAD_MODERATE;                                                    // встановлення помірного робочого рівня трафіку
      res.llmManagerDigest = "LLM DIGEST: Moderate flow. Operator pace optimal.";       // дайджест керівнику про оптимальний темп оператора
    } else {                                                                            // гілка повної відсутності черги очікування
      res.loadLevel = LOAD_LOW;                                                         // встановлення низького рівня завантаженості
      res.llmManagerDigest = "LLM DIGEST: Counter free. Zero wait for guests.";         // дайджест керівнику про миттєве обслуговування
    }                                                                                   // завершення класифікації завантаженості сервісної точки

    return res;                                                                         // повернення сформованого прогнозу штучного інтелекту
  }                                                                                     // завершення методу інтелектуальної оцінки черги
};                                                                                      // завершення класу прогнозування клієнтського трафіку

#endif                                                                                  // завершення блоку захисту заголовкового файлу